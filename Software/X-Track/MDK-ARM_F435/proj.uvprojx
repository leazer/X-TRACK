# Keil uVision project proj.uvprojx, settings and files
target X-Track (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: -AT32F435CGU7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.4
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: X-Track +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: LIBRARY_VERSION,ARDUINO=111,USE_STDPERIPH_DRIVER
  c misc: --gnu  --diag_warning=4017
  c include: ..\ArduinoAPI;.\Platform\Core;.\Platform;..\Libraries;..\Libraries\SdFat\src;..\USER\App;..\USER;..\Simulator\LVGL.Simulator;.\libraries\cmsis\cm4\device_support;.\libraries\cmsis\cm4\core_support;.\libraries\cmsis\cm4\core_support\dsp;.\libraries\drivers\inc;..\Libraries\AT32USB\usb_drivers\inc;..\Libraries\AT32USB\;..\Libraries\AT32USB\usbd_class\composite_cdc_msc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group USER
    ../USER/: main.cpp benchmark.inc
  group App
    ../USER/App/: Version.h App.cpp App.h
  group Config
    ../USER/App/Config/: Config.h
  group Common/DataPorc
    ../USER/App/Common/DataProc/: DP_LIST.inc DataProc.h DataProc_Def.h DataProc.cpp DP_Clock.cpp DP_GPS.cpp DP_IMU.cpp DP_MAG.cpp DP_MusicPlayer.cpp DP_Power.cpp DP_Recorder.cpp DP_SportStatus.cpp DP_Storage.cpp DP_SysConfig.cpp DP_TzConv.cpp DP_TrackFilter.cpp
  group Pages
    ../USER/App/Pages/: AppFactory.cpp AppFactory.h Page.h
  group Pages/StatusBar
    ../USER/App/Pages/StatusBar/: StatusBar.cpp StatusBar.h
  group Pages/Startup
    ../USER/App/Pages/Startup/: Startup.cpp Startup.h StartupModel.cpp StartupModel.h StartupView.cpp StartupView.h
  group Pages/MainMenu
    ../USER/App/Pages/MainMenu/: MainMenu.cpp MainMenu.h MainMenuModel.cpp MainMenuModel.h MainMenuView.cpp MainMenuView.h
  group Pages/Dialplate
    ../USER/App/Pages/Dialplate/: Dialplate.cpp Dialplate.h DialplateModel.cpp DialplateModel.h DialplateView.cpp DialplateView.h
  group Pages/LiveMap
    ../USER/App/Pages/LiveMap/: LiveMap.cpp LiveMap.h LiveMapModel.cpp LiveMapModel.h LiveMapView.cpp LiveMapView.h
  group Pages/SystemInfos
    ../USER/App/Pages/SystemInfos/: SystemInfos.cpp SystemInfos.h SystemInfosModel.cpp SystemInfosModel.h SystemInfosView.cpp SystemInfosView.h
  group Pages/_Template
    ../USER/App/Pages/_Template/: Template.cpp Template.h TemplateModel.cpp TemplateModel.h TemplateView.cpp TemplateView.h
  group Resource
    ../USER/App/Resource/: ResourcePool.cpp ResourcePool.h
  group Resource/Font
    ../USER/App/Resource/Font/: font_bahnschrift_13.c font_bahnschrift_17.c font_bahnschrift_32.c font_bahnschrift_65.c font_agencyb_36.c
  group Resource/Image
    ../USER/App/Resource/Image/: img_src_gps_arrow_dark.c img_src_gps_arrow_default.c img_src_gps_arrow_light.c img_src_gps_pin.c img_src_alarm.c img_src_battery.c img_src_locate.c img_src_menu.c img_src_origin_point.c img_src_satellite.c img_src_stop.c img_src_trip.c img_src_pause.c img_src_start.c img_src_battery_info.c img_src_bicycle.c img_src_compass.c img_src_gyroscope.c img_src_map_location.c img_src_storage.c img_src_system_info.c img_src_time_info.c img_src_sd_card.c
  group Utils/DataCenter
    ../USER/App/Utils/DataCenter/: Account.cpp Account.h DataCenter.cpp DataCenter.h DataCenterLog.h
    ../USER/App/Utils/DataCenter/PingPongBuffer/: PingPongBuffer.c PingPongBuffer.h
  group Utils/Filters
    ../USER/App/Utils/Filters/: Filters.h FilterBase.h HysteresisFilter.h LowpassFilter.h MedianFilter.h MedianQueueFilter.h SlidingFilter.h
  group Utils/GPX
    ../USER/App/Utils/GPX/: GPX.cpp GPX.h
  group Utils/GPX_Parser
    ../USER/App/Utils/GPX_Parser/: GPX_Parser.cpp GPX_Parser.h
  group Utils/lv_allocator
    ../USER/App/Utils/lv_allocator/: lv_allocator.h
  group Utils/lv_anim_label
    ../USER/App/Utils/lv_anim_label/: lv_anim_label.c lv_anim_label.h
  group Utils/lv_ext
    ../USER/App/Utils/lv_ext/: lv_anim_timeline_wrapper.c lv_obj_ext_func.cpp
  group Utils/lv_img_png
    ../USER/App/Utils/lv_img_png/: lv_img_png.cpp lv_img_png.h
    ../USER/App/Utils/lv_img_png/PNGdec/src/: adler32.c crc32.c crc32.h infback.c inffast.c inffast.h inffixed.h inflate.c inflate.h inftrees.c inftrees.h png.inl PNGdec.cpp PNGdec.h zconf.h zlib.h zutil.c zutil.h
  group Utils/llv_poly_line
    ../USER/App/Utils/lv_poly_line/: lv_poly_line.cpp lv_poly_line.h
  group Utils/MapConv
    ../USER/App/Utils/MapConv/: MapConv.h MapConv.cpp
    ../USER/App/Utils/MapConv/GPS_Transform/: GPS_Transform.h GPS_Transform.c
    ../USER/App/Utils/MapConv/TileSystem/: TileSystem.h TileSystem.cpp
  group Utils/new
    ../USER/App/Utils/new/: new.cpp
  group Utils/PageManager
    ../USER/App/Utils/PageManager/: PageManager.h PageFactory.h PageBase.h PM_Log.h PageBase.cpp PM_Anim.cpp PM_Base.cpp PM_Drag.cpp PM_Router.cpp PM_State.cpp
  group Utils/PointContainer
    ../USER/App/Utils/PointContainer/: PointContainer.cpp PointContainer.h
  group Utils/ResourceManager
    ../USER/App/Utils/ResourceManager/: ResourceManager.cpp ResourceManager.h
  group Utils/StorageService
    ../USER/App/Utils/StorageService/: StorageService.cpp StorageService.h
  group Utils/TonePlayer
    ../USER/App/Utils/TonePlayer/: TonePlayer.cpp TonePlayer.h
  group Utils/Time
    ../USER/App/Utils/Time/: DateStrings.cpp Time.cpp Time.h TimeLib.h
  group Utils/TileConv
    ../USER/App/Utils/TileConv/: TileConv.cpp TileConv.h
  group Utils/TrackFilter
    ../USER/App/Utils/TrackFilter/: TrackFilter.h TrackLineFilter.cpp TrackLineFilter.h TrackPointFilter.cpp TrackPointFilter.h
  group HAL
    ../USER/HAL/: HAL_Config.h HAL.h HAL.cpp HAL_Audio.cpp HAL_Backlight.cpp HAL_Buzz.cpp HAL_Clock.cpp HAL_Encoder.cpp HAL_FaultHandle.cpp HAL_GPS.cpp HAL_I2C_Scan.cpp HAL_IMU.cpp HAL_MAG.cpp HAL_Memory.cpp HAL_SD_CARD.cpp rt_sys.cpp HAL_LED.cpp HAL_TouchPad.cpp
    ./Platform/HAL/: HAL_Display.cpp HAL_Power.cpp
  group lvgl
    ../Simulator/LVGL.Simulator/: lv_conf.h
    ../Simulator/LVGL.Simulator/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Simulator/LVGL.Simulator/lvgl/src/draw/: lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c lv_draw.c lv_draw_transform.c lv_draw_mask.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/led/: lv_led.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/list/: lv_list.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/win/: lv_win.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/: lv_extra.c
    ../Simulator/LVGL.Simulator/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Simulator/LVGL.Simulator/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Simulator/LVGL.Simulator/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Simulator/LVGL.Simulator/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/span/: lv_span.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Simulator/LVGL.Simulator/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Simulator/LVGL.Simulator/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_gradient.c lv_draw_sw_transform.c
  group lvgl/demos/benchmark
    ../Simulator/LVGL.Simulator/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../Simulator/LVGL.Simulator/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group lv_port
    ../USER/lv_port/: lv_port.h lv_port.cpp lv_port_fs_sdfat.cpp lv_port_indev.cpp
    ./Platform/lv_port/: lv_port_disp.cpp
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/Adafruit_ST7789/: Adafruit_ST7789.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/LIS3MDL/: LIS3MDL.cpp
    ../Libraries/LSM6DSM/: LSM6DSM.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/TinyGPSPlus/src/: TinyGPS++.cpp
    ../Libraries/StackInfo/: StackInfo.c
  group SdFat
    ../Libraries/SdFat/src/FatLib/: FatFile.cpp FatFileLFN.cpp FatFilePrint.cpp FatFileSFN.cpp FatVolume.cpp FmtNumber.cpp fstream.cpp istream.cpp ostream.cpp StdioStream.cpp
    ../Libraries/SdFat/src/SdCard/: SdSpiCard.cpp SdSpiCardEX.cpp
    ../Libraries/SdFat/src/SpiDriver/: SdSpiSTM32.cpp
    ../Libraries/SdFat/src/: MinimumSerial.cpp
  group cm_backtrace
    ../Libraries/cm_backtrace/: cmb_cfg.h cm_backtrace.c
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp Stream.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Platform/Core
    ./Platform/Core/: mcu_core.h mcu_type.h adc.c at32f435_437_clock.c delay.c exti.c gpio.c mcu_core.c pwm.c rtc.c timer.c wdg.c HardwareSerial.cpp SPI.cpp Tone.cpp HardwareCAN.cpp USB_Device.c
  group Platform/AT32USB
    ../Libraries/AT32USB/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
    ../Libraries/AT32USB/usbd_class/composite_cdc_msc/: cdc_msc_class.c cdc_msc_desc.c msc_bot_scsi.c
  group Platform
    ./Platform/: mcu_config.h
  group README
    ../: README.md
  group HalLib
    ./libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
    ./libraries/cmsis/cm4/device_support/: at32f435_437.h system_at32f435_437.c
    ./libraries/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group Utils/CST836U
    ../Libraries/CST836U/: CST836U.cpp CST836U.h
